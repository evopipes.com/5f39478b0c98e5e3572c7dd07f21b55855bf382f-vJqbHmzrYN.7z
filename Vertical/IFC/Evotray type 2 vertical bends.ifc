Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: cec9610d-a073-4f6c-89fa-90a45d370c0f, NumberOfSaves: 7], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: Project Number
Time: 2024-03-04T10:37:59
Written by: ODA IFC SDK 22.8
Made in: 22.1.50.17 - Exporter 22.6.2.0 - Alternate UI 22.6.2.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 32, 376708; RefLongitude: -71, -3, -31, -74829; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcDistributionPort (10)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_864562_1
Port_864810_1
Port_864850_1
Port_864905_1
Port_864947_1
Port_873480_1
Port_873662_1
Port_873710_1
Port_873770_1
Port_873811_1

# IfcFlowSegment: Evotray type 2 vertical bend down:Evotray type 2 vertical bend down (5)
In: Level 1
Type - Material: EVOTRAY
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Copyrite: @2008 SIA Evopipes; Fire resistence: Class K1- according to DIN 53438-2; Hight: 230mm; Length: ~1000mm; Manufacturer: Evopipes; Material: Polypropylene (PP), UV stabilized; Mechanical strength: ≥ 12 kN; Thermal stability: -30°C to +95°C; Type Name: Evotray type 2 vertical bend down; URL: www.evopipes.lv; Weight: 9kg; Width: 340mm
Type - Other - Category: Cable Tray Fittings; Family Name: Evotray type 2 vertical bend down
Type - Pset_ManufacturerTypeInformation - Manufacturer: Evopipes
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Evotray type 2 vertical bend down; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 22.5 mm; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: no
Dimensions - Area: 5.32025 m2; Size: 100 mmx100 mm; Volume: 0.193159 m3
Other - Family: Evotray type 2 vertical bend down; Family and Type: Evotray type 2 vertical bend down: Evotray type 2 vertical bend down; Type: Evotray type 2 vertical bend down; Type Id: 864546
Name (Evotray type 2 vertical bend down:Evotray type 2 vertical bend down:...) | 15° bend | 30° bend | 45° bend | 60° bend | 90° bend
864562 | no | no | no | no | yes
864810 | yes | no | no | no | no
864850 | no | yes | no | no | no
864905 | no | no | yes | no | no
864947 | no | no | no | yes | no

# IfcFlowSegment: Evotray type 2 vertical bend up:Evotray type 2 vertical bend up (5)
In: Level 1
Type - Material: EVOTRAY
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Copyrite: @2008 SIA Evopipes; Fire resistence: Class K1- according to DIN 53438-2; Hight: 230mm; Length: ~1000mm; Manufacturer: Evopipes; Material: Polypropylene (PP), UV stabilized; Mechanical strength: ≥ 12 kN; Thermal stability: -30°C to +95°C; Type Name: Evotray type 2 vertical bend up; URL: www.evopipes.lv; Weight: 9kg; Width: 340mm
Type - Other - Category: Cable Tray Fittings; Family Name: Evotray type 2 vertical bend up
Type - Pset_ManufacturerTypeInformation - Manufacturer: Evopipes
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Evotray type 2 vertical bend up; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 22.5 mm; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: no
Dimensions - Area: 5.02179 m2; Size: 100 mmx100 mm; Volume: 0.188723 m3
Other - Family: Evotray type 2 vertical bend up; Family and Type: Evotray type 2 vertical bend up: Evotray type 2 vertical bend up; Type: Evotray type 2 vertical bend up; Type Id: 873249
Name (Evotray type 2 vertical bend up:Evotray type 2 vertical bend up:...) | 15° bend | 30° bend | 45° bend | 60° bend | 90° bend
873480 | no | no | no | no | yes
873662 | yes | no | no | no | no
873710 | no | yes | no | no | no
873770 | no | no | yes | no | no
873811 | no | no | no | yes | no
