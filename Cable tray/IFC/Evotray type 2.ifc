Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 50e04fb8-6764-4487-b5eb-92c672dc3312, NumberOfSaves: 3], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: Project Number
Time: 2024-02-15T12:24:18
Written by: ODA IFC SDK 22.8
Made in: 22.1.50.17 - Exporter 22.6.2.0 - Alternate UI 22.6.2.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 32, 376708; RefLongitude: -71, -3, -31, -74829; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_813078_3
Port_813078_4

# IfcFlowSegment: Evotray with cover:Evotray type 2, Evotray with cover:Evotray type 2:813078
In: Level 1
Type - Material: EVOTRAY
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Hight logo: 246 mm; Width cover: 295 mm; Width inside: 240 mm; Width outside: 340 mm
Type - Identity Data - Copyrite: @2008 SIA Evopipes; Fire resistence: Class K1- according to DIN 53438-2; Hight: 230mm; Length: ~1000mm; Manufacturer: Evopipes; Material: Polypropylene (PP), UV stabilized; Mechanical strength: ≥ 12 kN; Thermal stability: -30°C to +95°C; Type Name: Evotray type 2; URL: www.evopipes.lv; Weight: 9kg; Width: 340mm
Type - Other - Category: Cable Tray Fittings; Family Name: Evotray with cover
Type - Pset_ManufacturerTypeInformation - Manufacturer: Evopipes
Type - Pset_ProductRequirements - Category: Cable Tray Fittings
Pset_DistributionFlowElementCommon - Reference: Evotray type 2; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 11 mm; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Level: Level 1
Phasing - Phase Created: New Construction
Graphics - Use Annotation Scale: no
Dimensions - Area: 1.26657 m2; Size: 100 mmx100 mm-100 mmx100 mm; Volume: 0.0337491 m3
Other - Family: Evotray with cover; Family and Type: Evotray with cover: Evotray type 2; Type: Evotray type 2; Type Id: 806266
